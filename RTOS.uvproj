# Keil uVision project RTOS.uvproj, settings and files
target RTOS811 (ARM-ADS)
  device: LM3S8962 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RTOS811
  c flags: Optim=1
  c include: ..;..\..\..;..\..\..\ValvanoWare
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Code
    ./: user.c osasm.s os.c ADC.c UART2.c StartupLab2.s rit128x96x4.c Output.c Debug.c
    ../: cr4_fft_64_stm32.s PID_stm32.s
  group Library
    ../../driverlib/rvmdk/: driverlib.lib
